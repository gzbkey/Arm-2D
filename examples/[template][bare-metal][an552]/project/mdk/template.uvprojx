# Keil uVision project template.uvprojx, settings and files
target AN547-AN552 (6240000::V6.24::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: Optim=8 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,__USE_AN547__
  c misc: -Wno-padded
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3;..\..\..\common\scenes\meter;..\..\..\common\scenes\fitness;..\..\..\common\scenes\watch;..\..\..\demos;..\..\..\common\scenes\alarm_clock;..\..\..\common\scenes\histogram;..\..\..\common\scenes\fan;..\..\..\common\scenes\bubble_charging;.;..\..\..\common\scenes\knob;..\..\..\common\scenes\animate_background;..\..\..\common\opcodes
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
  group Source Files
    ../../: main.c app_cfg.h
    ../../../common/scenes/alarm_clock/: arm_2d_scene_alarm_clock.c arm_2d_scene_alarm_clock.h
    ../../../common/scenes/histogram/: arm_2d_scene_histogram.c arm_2d_scene_histogram.h
    ../../../common/scenes/meter/: arm_2d_scene_meter.c arm_2d_scene_meter.h
    ../../../common/scenes/fitness/: arm_2d_scene_fitness.c arm_2d_scene_fitness.h
    ../../../common/scenes/watch/: arm_2d_scene_watch.c arm_2d_scene_watch.h
    ../../../common/scenes/fan/: arm_2d_scene_fan.c arm_2d_scene_fan.h
    ../../../common/scenes/bubble_charging/: arm_2d_scene_bubble_charging.c arm_2d_scene_bubble_charging.h
    ../../../common/scenes/knob/: arm_2d_scene_knob.c arm_2d_scene_knob.h
    ../../../common/scenes/animate_background/: arm_2d_scene_animate_background.h arm_2d_scene_animate_background_vres.c arm_2d_scene_animate_background.c
    ../../../common/asset/: arm_2d_asset_knob_circle_quater.c arm_2d_asset_radial_line_cover.c arm_2d_asset_wedge_pattern.c
  group platform
    ../../../common/platform/: app_platform.c Board_GLCD.h platform.h
  group bsp_mps3
    ../../../common/platform/mps3/: GLCD_V2M-MPS3_AN540.c platform_mps3.c stdout_USART.c GLCD_Config.h
target AN542 (6240000::V6.24::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: as above
  output: template
  c flags: as above
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,__USE_AN547__
  c misc: -Wno-padded
  c include: as above
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\an542.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
software components: Acceleration:Arm-2D Demos:Atom 1.2.1, Acceleration:Arm-2D Demos:AudioMark 1.0.5, Acceleration:Arm-2D Demos:Balls 1.0.0, Acceleration:Arm-2D Demos:Basics 2.0.0, Acceleration:Arm-2D Demos:Blink 2.4.2, Acceleration:Arm-2D Demos:Compass 1.3.1, Acceleration:Arm-2D Demos:ConsoleWindow 1.1.1, Acceleration:Arm-2D Demos:Decoding JPG with TJpgDec 1.1.0, Acceleration:Arm-2D Demos:Filters 1.2.2, Acceleration:Arm-2D Demos:Flight Attitude Instrument 1.5.0, Acceleration:Arm-2D Demos:Gas Gauge 1.2.1, Acceleration:Arm-2D Demos:Hollow Out List 1.3.0, Acceleration:Arm-2D Demos:IIR Blur 1.0.1, Acceleration:Arm-2D Demos:Listview 1.0.3, Acceleration:Arm-2D Demos:Loading Lossless image with QOI 1.3.1, Acceleration:Arm-2D Demos:Mask Generator 1.2.0, Acceleration:Arm-2D Demos:Matrix 2.0.1, Acceleration:Arm-2D Demos:Menu 1.1.1, Acceleration:Arm-2D Demos:Monochrome 1.6.2, Acceleration:Arm-2D Demos:Music Player 3.0.0, Acceleration:Arm-2D Demos:Panel 1.3.0, Acceleration:Arm-2D Demos:Progress and Status 2.5.1, Acceleration:Arm-2D Demos:QRCode 1.0.0, Acceleration:Arm-2D Demos:Radars 4.3.0, Acceleration:Arm-2D Demos:Ring Indicator 1.1.2, Acceleration:Arm-2D Demos:Ruler 1.4.0, Acceleration:Arm-2D Demos:Shaped Panel 1.0.0, Acceleration:Arm-2D Demos:Showing Animation with TJpgDec 2.3.0, Acceleration:Arm-2D Demos:Space Badge 2.0.0, Acceleration:Arm-2D Demos:Text Reader 2.0.0, Acceleration:Arm-2D Demos:Transform 2.1.3, Acceleration:Arm-2D Demos:User Defined OPCODE 3.0.0, Acceleration:Arm-2D Demos:Virtual Resources 2.0.0, Acceleration:Arm-2D Demos:Watch Face 01 1.2.2, Acceleration:Arm-2D Demos:Waveform 2.1.0, Acceleration:Arm-2D Extras:Controls 2.16.2, Acceleration:Arm-2D Extras:LCD ASCII Printf 3.0.2, Acceleration:Arm-2D Extras:Loaders 5.6.11, Acceleration:Arm-2D Helper:Display Adapter 4.4.3, Acceleration:Arm-2D Helper:PFB 3.2.9, Acceleration:Arm-2D Render Test:Font Rendering 0.9.0, Acceleration:Arm-2D Render Test:Large LMSK 1.4.1, Acceleration:Arm-2D Render Test:Lossless Compressed Mask(LMSK) 1.1.0, Acceleration:Arm-2D Render Test:Tile Paving 2.1.0, Acceleration:Arm-2D Render Test:Transform Inspection 1.0.0, Acceleration:Arm-2D:Alpha-Blending 1.2.6, Acceleration:Arm-2D:Core 1.2.6, Acceleration:Arm-2D:Filter 1.2.6, Acceleration:Arm-2D:Transform 1.2.6, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Device:Definition 2.0.0, Device:Native Driver:SysCounter 1.1.0, Device:Native Driver:SysTimer 1.1.0, Device:Native Driver:Timeout 1.0.0, Device:Startup 2.0.0, Utilities:perf_counter:Core 2.5.5-dev, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
