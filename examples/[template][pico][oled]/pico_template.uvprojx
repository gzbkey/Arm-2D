# Keil uVision project pico_template.uvprojx, settings and files
target OLED_12864 (6240000::V6.24::ARMCLANG)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: pico_template
  BeforeMake: $Stools\pio_all.bat
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: __RP2040_USE_OLED_1IN3__=1
  c include: .\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\RTE\Device\RP2040_Core0\rp2040.sct
  group Application
    ./: main.c
  group BSP
    ./bsp/lib/: RP2040_bsp.lib
    ./bsp/: rp2040_bsp_default.c bsp.h
software components: Acceleration:Arm-2D Demos:Monochrome 1.6.2, Acceleration:Arm-2D Extras:Controls 2.16.2, Acceleration:Arm-2D Extras:LCD ASCII Printf 3.0.2, Acceleration:Arm-2D Extras:Loaders 5.6.11, Acceleration:Arm-2D Helper:Display Adapter 4.4.3, Acceleration:Arm-2D Helper:PFB 3.2.9, Acceleration:Arm-2D:Alpha-Blending 1.2.6, Acceleration:Arm-2D:Core 1.2.6, Acceleration:Arm-2D:Filter 1.2.6, Acceleration:Arm-2D:Transform 1.2.6, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.5.5-dev, Device:Pico Board 1.5.1, Device:Pico SDK 1.5.1, Device:Startup 1.1.0
